# Repository der-pw/HM-LC-Sw1-Pl-DN-R1_S26

File README.md:

# HM-LC-Sw1-Pl-DN-R1_S26          

### Dieses Projekt beschreibt den Umbau eines Sonoff S26 Zwischenstecker zum HM-LC-Sw1-Pl-DN-R1_S26  
... und basiert auf der hervorragenden Arbeit von [pa-pa](https://github.com/pa-pa/AskSinPP), [Jérôme](https://github.com/jp112sdl/Beispiel_AskSinPP), sowie meiner Inspirationsquelle [stan23](https://github.com/stan23) mit seinem Umbau OBI-Wifi-Stecker zu [HM-LC-Sw1-Pl-DN-R1_OBI](https://github.com/stan23/HM-LC-Sw1-Pl-DN-R1_OBI).

Weitere Informationen gibt es im [Wiki](https://github.com/der-pw/HM-LC-Sw1-Pl-DN-R1_S26/wiki).

Dieses Werk ist lizenziert unter einer [Creative Commons Namensnennung - Nicht-kommerziell - Weitergabe unter gleichen Bedingungen 4.0 International Lizenz](http://creativecommons.org/licenses/by-nc-sa/4.0/).

## KiCad design Platine/HM-LC-Sw1-Pl-DN-R1_S26.kicad_pcb

Parts:
C1: 10u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C2, C3, C4, C5: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
CC1101: CC1101-Homebrew; CC1101
J1: FTDI; PinHeader_1x05_P2.54mm_Vertical
J3: Reset; Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork
J4: Conn_01x06_Female; Sonoff_S26_Connector
R1: 10k; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm

Connections:
/BUTTON(J4): J4.6, U1.2 (PD4)
/CSN: CC1101.8 (CSN), U1.14 (PB2)
/DTR: C4.1, J1.1
/GDO0: CC1101.7 (GDO0), U1.32 (PD2)
/J10: J4.3
/LED(J5): J4.2, U1.9 (PD5)
/MISO: CC1101.5 (MISO), U1.16 (PB4)
/MOSI: CC1101.3 (MOSI), U1.15 (PB3)
/RELAY(J3): J4.4, U1.12 (PB0)
/RXD: J1.3, U1.30 (PD0)
/Reset: C4.2, J3.1, R1.2, U1.29 (~RESET~/PC6)
/SCLK: CC1101.4 (SCLK), U1.17 (PB5)
/TXD: J1.2, U1.31 (PD1)
GND: C1.2, C2.2, C3.2, C5.2, CC1101.2 (GND), J1.5, J1.6, J4.5, U1.3 (GND), U1.5 (GND), U1.21 (GND); also elsewhere on the board
VCC: C1.1, C2.1, C3.1, C5.1, CC1101.1 (VCC), J1.4, J4.1, R1.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U1.20 (AREF)

Notes on the sheet:
FTDI
0.2

Board: 2 copper layers, 20.1 x 29.7 mm, 12 parts (9 on the bottom side), 14 nets.

Other parts of the board:
U2: CC1101-; CC1101_SMD_Kopfkontakte

Their connections:
GND: U2.10, U2.11; also elsewhere on the board

## Commit log

2019-01-20 more pics
2019-01-25 upload pictures
2019-01-25 upload
2019-01-25 evaluation finished
2019-01-25 change Device Model
2020-02-11 Update HM-LC-Sw1-Pl-DN-R1_S26.ino
    change firmware version to 2.6

Notices in the files:
Platine/HM-LC-Sw1-Pl-DN-R1_S26.kicad_pcb:
CC BY-NC-SA 4.0
README.md:
License: CC BY-NC-SA 4.0
Creative Commons Lizenzvertrag
